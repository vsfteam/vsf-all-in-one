# IAR project project_l0.ewp, settings and files
configuration at_start_f402 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F402RCT7_v2 ArteryTek AT32F402RCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F402RCT7; USE_STDPERIPH_DRIVER; AT_START_F402_V1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\inc; ..\..\..\..\project\at32f402_405_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_l0.hex
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: project_l0.out
  ILINK.IlinkIcfFile: AT32F402xC_slib.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f405 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F405RCT7_v2 ArteryTek - AT32F405RCT7
  ICCARM.CCDefines: AT32F405RCT7; USE_STDPERIPH_DRIVER; AT_START_F405_V1; ARM_MATH_CM4
  ILINK.IlinkIcfFile: AT32F405xC_slib.icf
  group bsp
    ../../../../project/at32f402_405_board/: at32f402_405_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f402_405.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group firmware
    ../../../../libraries/drivers/src/: at32f402_405_crm.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_misc.c at32f402_405_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c at32f402_405_clock.c at32f402_405_int.c main.c math_helper.c
